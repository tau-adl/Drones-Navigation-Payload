# Repository tau-adl/Drones-Navigation-Payload

File README.md:

# Drones-Navigation-Payload
The goal of the project is to build a payload taken by a drone that transmit both IMU and Images to a python script on a computer. 
Later, this information will be processed by ROS environment for navigation with SLAM algorithm. 

The Hardware for this project is based on the OpenMV(c) cH7 camera circuit loaded with global shutter camera, wifi shield and MPU6050 IMU sensor.

The repo cantains python script to be run as "ground-station" and the original firmware that runs on the main MCU.

## EAGLE design datasheets/openmv/base.brd

Parts:
C1, C4: 1uF; 0603-CAP
C2, C44: 22uF; 0805
C3, C12: 10uF; 0805
C5, C6, C7, C8, C9, C10, C13: 0.1uF; 0603-CAP
C11, C14, C15: 47uF; EIA3216
C40, C41: 12pF; 0603-CAP
C48, C49: 2.2uF; 0603-CAP
D3: SDM2U20SD3-7; SOD-323
H1, H2: MOUNT-PAD-ROUND2.8; 2,8-PAD
JP1, JP2: PINHD-1X8; 1X08
JP3: PINHD-1X6; 1X06
L1, L2: MPZ1608S181ATAH0; 0603
L3: 4.7uH/1.4A; 1007
LED1: LED-TRICOLOR; LED-TRICOLOR-SMD-MF
LED2, LED3: VSMY12850; LED-1206
LOGO1: OSHW_LOGO_FILLX0100-NT; OSHW_FILLX100_NOTEXT
M1, M2: 9774030243R; 9774030151R
Q1: BSS138; SOT23-3
Q2: Si2301BDS; SOT23-3
R1: 10R; 0603-RES
R2, R9: 10K; 0603-RES
R3, R4: 4.7K; 0603-RES
R5: 100K; 0603-RES
R10: 453K; 0603-RES
RN1: 220R; EXBV8V
RN2, RN3: 10K; EXBV8V
U1: STM32H743VIT6; LQFP100
U5: TPS731XX; SOT23-5
U8: PAM2305AABADJ; TSOT25
X1: MF-CON-MICROUSB-RIGHT; MICROUSB-RIGHT
X2: USD-1040310811; 1040310811
X3: DF12-36-DS
X4: S2B-PH-K-S(LF)(SN); JST-PH-2-THM-RA
Y1: 7S-12.000MAHE-T; CRYSTAL-2.5X2.0

Connections:
BOOT0: JP2.2, RN3.3 (1), U1.94 (BOOT0)
DAC: JP1.7, U1.29 (PA5/SPI1_SCK/OTG_HS_ULPI_CK/TIM2_CH1_ET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)
DCMI_CLK: U1.67 (PA8/MCO1/USART1_CK/TIM1_CH1/I2C3_SCL/OT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), X3.12
DCMI_D0: U1.63 (PC6/I2S2_MCK/TIM8_CH1/SDIO_D6/USART6_TX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), X3.31
DCMI_D1: U1.64 (PC7/I2S3_MCK/TIM8_CH2/SDIO_D7/USART6_RX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), X3.29
DCMI_D2: U1.97 (PE0/TIM4_ETR/FSMC_NBL0/DCMI_D2), X3.35
DCMI_D3: U1.98 (PE1/FSMC_NBL1/DCMI_D3), X3.28
DCMI_D4: U1.3 (PE4/TRACED1/FSMC_A20/DCMI_D4), X3.26
DCMI_D5: U1.92 (PB6/I2C1_SCL/TIM4_CH1/CAN2_TX/OTG_FS_IN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), X3.33
DCMI_D6: U1.4 (PE5/FSMC_A21/TIM9_CH1/DCMI_D6), X3.24
DCMI_D7: U1.5 (PE6/FSMC_A22/TIM9_CH2/DCMI_D7), X3.22
DCMI_FSIN: JP2.3, X3.23
DCMI_HSYNC: U1.28 (PA4/SPI1_NSS/SPI3_NSS/USART2_CK/DCMI_HS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), X3.18
DCMI_PCLK: U1.30 (PA6/SPI1_MISO/TIM8_BKIN/TIM13_CH1/DCMI_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), X3.14
DCMI_PWDN: U1.88 (PD7/USART2_CK/FSMC_NE1/FSMC_NCE2), X3.25
DCMI_RST: U1.69 (PA10/USART1_RX/TIM1_CH3/OTG_FS_ID/DCMI_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), X3.21
DCMI_VSYNC: U1.93 (PB7/I2C1_SDA/FSMC_NL/DCMI_VSYNC/USART1_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), X3.16
EXPST: U1.55 (PD8/FSMC_D13/USART3_TX)
FREX: U1.56 (PD9/FSMC_D14/USART3_RX)
FS_DM: U1.70 (PA11/USART1_CTS/CAN1_RX/TIM1_CH4/OTG_FS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), X1.2 (D-)
FS_DP: U1.71 (PA12/USART1_RTS/CAN1_TX/TIM1_ETR/OTG_FS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), X1.3 (D+)
GND: C1.2, C2.1, C3.1, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.C (-), C12.1, C13.2, C14.C (-), C15.C (-), C40.1, C41.1, C44.1, C48.2, C49.2, JP2.8, JP3.6, Q1.2 (S), R2.1, R5.1, R9.1, RN3.6 (2), U1.10 (VSS), U1.19 (VSSA), U1.26 (VSS), U1.49 (VSS), U1.74 (VSS), U1.99 (VSS), U5.2 (GND), U8.2 (GND), X1.5 (GND), X2.CD$2 (CD_POL), X2.G$1 (SHD), X2.G$2 (SHD), X2.G$3 (SHD), X2.G$4 (SHD), X2.P$6 (VSS), X3.5, X3.19, X3.27, X4.2 (1), Y1.2, Y1.4
GPIO1: U1.84 (PD3/FSMC_CLK/USART2_CTS)
GPIO2: U1.85 (PD4/FSMC_NOE/USART2_RTS)
GPIO3: U1.82 (PD1FSMC_D3/CAN1_TX)
I2C1_SCL: R3.2, U1.95 (PB8/TIM4_CH3/SDIO_D4/TIM10_CH1/DCMI_D6/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), X3.32
I2C1_SDA: R4.2, U1.96 (PB9/SPI2_NSS/I2S2_WS/TIM4_CH4/TIM11_CH1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), X3.34
I2C2_SCL: JP1.5, U1.46 (PB10/SPI2_SCK/I2S2_CK/I2C2_SCL/USART3_T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)
I2C2_SDA: JP1.6, U1.47 (PB11/I2C2_SDA/USART3_RX/OTG_HS_ULPI_D4/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)
LED_B: RN1.6 (2), U1.17 (PC2/SPI2_MISO/OTG_HS_ULPI_DIR/TH_MII_TX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)
LED_G: RN1.7 (2), U1.16 (PC1/ETH_MDC/ADC123_IN11)
LED_IR: RN1.5 (2), U1.1 (PE2/TRACECLK/FSMC_A23/ETH_MII_TXD3)
LED_R: RN1.8 (2), U1.15 (PC0/OTG_HS_ULPI_STP/ADC123_IN10)
unnamed: C40.2, U1.13 (PH1/OSC_OUT), Y1.3 (2)
unnamed: C41.2, U1.12 (PH0/OSC_IN), Y1.1
unnamed: Q1.1 (G), R2.2, RN1.4 (1)
unnamed: LED1.B (BLU), RN1.3 (1)
unnamed: L2.1, X1.1 (5V)
unnamed: LED1.R (RED), RN1.1
unnamed: LED1.G (GRN), RN1.2 (1)
unnamed: LED3.C, R1.2
unnamed: C7.1, U5.4 (NR)
unnamed: C4.1, C5.1, L1.1, U1.20 (VREF), U1.21 (VDDA)
unnamed: R5.2, R10.1, U8.4 (VOUT/FB)
unnamed: Q1.3 (D), R1.1
unnamed: LED2.C, LED3.A
NRST: C1.1, JP2.1, JP3.4, RN3.4 (1), U1.14 (NRST)
RAW: C44.2, D3.1 (C), Q2.2 (S), U8.1 (VIN), U8.3 (EN)
RSVD1: X3.1
RSVD2: X3.3
RSVD3: X3.7
RSVD4: X3.9
RSVD5: X3.6
RSVD6: X3.8
SDIO_CLK: U1.80 (PC12/UART5_TX/SDIO_CK/DCMI_D9/SPI3_MOSI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), X2.P$5 (CLK)
SDIO_CMD: RN2.8 (2), U1.83 (PD2/TIM3_ETR/UART5_RXSDIO_CMD/DCMI_D11), X2.P$3 (CMD)
SDIO_D0: RN2.7 (2), U1.65 (PC8/TIM8_CH3/SDIO_D0/TIM3_CH3/USART6_CK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), X2.P$7 (DAT0)
SDIO_D1: RN2.6 (2), U1.66 (PC9/I2S_CKIN/MCO2/TIM8_CH4/SDIO_D1/I2C3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), X2.P$8 (DAT1)
SDIO_D2: RN3.8 (2), U1.78 (PC10/SPI3_SCK/I2S3_CK/UART4_TX/SDIO_D2/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), X2.P$1 (DAT2)
SDIO_D3: RN3.7 (2), U1.79 (PC11/UART4_RX/SPI3_MISO/SDIO_D3/DCMI_D4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), X2.P$2 (DAT3/CD)
SD_CD: RN2.5 (2), U1.81 (PD0/FSMC_D2/CAN1_RX), X2.CD$1 (CD)
SPI2_MISO: JP1.2, U1.53 (PB14/SPI2_MISO/TIM1_CH2N/TIM12_CH1/OTG_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)
SPI2_MOSI: JP1.1, U1.54 (PB15/SPI2_MOSI/I2S2_SD/TIM1_CH3N/TIM8_C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)
SPI2_NSS: JP1.4, U1.51 (PB12/SPI2_NSS/I2S2_WS/I2C2_SMBA/USART3_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)
SPI2_SCLK: JP1.3, U1.52 (PB13/SPI2_SCK/I2S2_CK/USART3_CTS/TIM1_C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)
SPI3_MISO: U1.90 (PB4/NJTRST/SPI3_MISO/TIM3_CH1/SPI1_MISO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), X3.15
SPI3_MOSI: U1.91 (PB5/I2C1_SMBA/TIM3_CH2/SPI1_MOSI/SPI3_M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), X3.17
SPI3_SCLK/TRACESWO: JP3.1, U1.89 (PB3/JTDO/TRACESWO/SPI3_SCK/I2S3_CK/TIM2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), X3.13
SPI3_SSEL: U1.77 (PA15/JTDI/SPI3_NSS/I2S3_WS/TIM2_CH1_ETR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), X3.11
SW: L3.1, U8.5 (SW)
SWCLK: JP3.2, U1.76 (PA14/JTCK-SWCLK)
SWDIO: JP3.3, U1.72 (PA13/JTMS-SWDIO)
TIM4_CH1: JP2.6, U1.59 (PD12/FSMC_A17/TIM4_CH1/USART3_RTS)
TIM4_CH2: JP2.5, U1.60 (PD13/FSMC_A18/TIM4_CH2)
TIM4_CH3: JP2.4, U1.61 (PD14/FSMC_D0/TIM4_CH3)
UART2_RX: U1.87 (PD6/FSMC_NWAIT/USART2_RX)
UART2_TX: U1.86 (PD5/FSMC_NWE/USART2_TX)
VBUS: L2.2, Q2.3 (D), U1.68 (PA9/USART1_TX/TIM1_CH2/I2C3_SMBA/DCMI_D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)
VCAP1: C49.1, U1.48 (VCAP)
VCAP2: C48.1, U1.73 (VCAP)
VCC: C2.2, C3.2, C6.1, C8.1, C9.1, C10.1, C11.A (+), C13.1, C14.A (+), C15.A (+), JP1.8, JP3.5, L1.2, L3.2, LED1.A, LED2.A, R3.1, R4.1, R10.2, RN2.1, RN2.2 (1), RN2.3 (1), RN2.4 (1), RN3.1, RN3.2 (1), RN3.5 (2), U1.6 (VBAT), U1.11 (VDD), U1.27 (VDD), U1.50 (VDD), U1.75 (VDD), U1.100 (VDD), U5.1 (IN), U5.3 (EN), X2.P$4 (VDD), X3.2, X3.10, X3.20, X3.30, X3.36
VDDA: C12.2, U5.5 (OUT), X3.4
VIN: D3.2 (A), JP2.7, Q2.1 (G), R9.2, X4.1 (2)

Notes on the sheet:
PC13, PC14, PC15 and PI8 limited to 3mA/2MHz
SD CARD
Y[9:2] for 8-bit YUV or RGB (Y9 MSB, Y2 LSB)
DVDD not connected, using internal regulator
Notes:
IMAGE SENSOR CONNECTOR
STM32F7xx MCU
IR-RGB LEDs
USB & POWER SUPPLY
DEBUG HEADER
I/O HEADERS
No external termination series resistors are required on DP (D+) and DM (D-) pins since the matching impedance is included in the embedded driver.
The output voltage is calculated as below: Vo = 0.6 * (1+R10/R5)

Board: 4 copper layers, 35.6 x 44.5 mm, 60 parts (4 on the bottom side), 70 nets.

Other parts of the board:
U$1: WEEE
U$2: ROHS
U$3: OMV-LOGO
U$4: OMV-LOGO-SMALL
U$6: OMV-LOGO-BIG

## Code that names these connections

File drone-payload-fw/drone-payload-fw.ioc (part):

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Mcu.Name=STM32H743VITx
Mcu.Package=LQFP100
Mcu.UserName=STM32H743VITx
PA0.Mode=Asynchronous
PA0.Signal=UART4_TX
PA1.Mode=Asynchronous
PA1.Signal=UART4_RX
PA10.GPIOParameters=GPIO_Label
PA10.GPIO_Label=DCMI_RESET
PA10.Signal=GPIO_Output
PA13\ (JTMS/SWDIO).Mode=Serial_Wire
PA13\ (JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14\ (JTCK/SWCLK).Mode=Serial_Wire
PA14\ (JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA4.GPIOParameters=GPIO_Speed
PA4.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PA4.Mode=Slave_8_bits_External_Synchro
PA4.Signal=DCMI_HSYNC
PA5.GPIOParameters=GPIO_Label
PA5.GPIO_Label=WIFI_CHIP_EN
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Speed
PA6.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PA6.Mode=Slave_8_bits_External_Synchro
PA6.Signal=DCMI_PIXCLK
PA8.GPIOParameters=GPIO_Speed,GPIO_Label
PA8.GPIO_Label=DCMI_PCLK
PA8.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PA8.Signal=S_TIM1_CH1
PB10.GPIOParameters=GPIO_Speed,GPIO_PuPd
PB10.GPIO_PuPd=GPIO_PULLUP
PB10.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB10.Mode=I2C
PB10.Signal=I2C2_SCL
PB11.GPIOParameters=GPIO_Speed,GPIO_PuPd
PB11.GPIO_PuPd=GPIO_PULLUP
PB11.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB11.Mode=I2C
PB11.Signal=I2C2_SDA
PB12.GPIOParameters=GPIO_Label
PB12.GPIO_Label=SPI2_NSS
PB12.Signal=GPIO_Output
PB13.GPIOParameters=GPIO_Speed
PB13.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB13.Mode=Full_Duplex_Master
PB13.Signal=SPI2_SCK
PB14.GPIOParameters=GPIO_Speed
PB14.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB14.Mode=Full_Duplex_Master
PB14.Signal=SPI2_MISO
PB15.GPIOParameters=GPIO_Speed
PB15.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB15.Mode=Full_Duplex_Master
PB15.Signal=SPI2_MOSI
PB6.GPIOParameters=GPIO_Speed,GPIO_FM6
PB6.GPIO_FM6=SYSCFG_PMCR_I2C_PB6_FMP
PB6.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB6.Mode=Slave_8_bits_External_Synchro
PB6.Signal=DCMI_D5
PB7.GPIOParameters=GPIO_Speed,GPIO_FM7
PB7.GPIO_FM7=SYSCFG_PMCR_I2C_PB7_FMP
PB7.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PB7.Mode=Slave_8_bits_External_Synchro
PB7.Signal=DCMI_VSYNC
PB8.GPIOParameters=GPIO_Speed,GPIO_PuPd,GPIO_FM8
PB8.GPIO_FM8=__NULL
PB8.GPIO_PuPd=GPIO_NOPULL
PB8.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PB8.Mode=I2C
PB8.Signal=I2C1_SCL
PB9.GPIOParameters=GPIO_Speed,GPIO_PuPd,GPIO_FM9
PB9.GPIO_FM9=__NULL
PB9.GPIO_PuPd=GPIO_NOPULL
PB9.GPIO_Speed=GPIO_SPEED_FREQ_LOW
PB9.Mode=I2C
PB9.Signal=I2C1_SDA
PC0.GPIOParameters=PinState,GPIO_Label
PC0.GPIO_Label=LED_R
PC0.PinState=GPIO_PIN_SET
PC0.Signal=GPIO_Output
PC1.GPIOParameters=PinState,GPIO_Label
PC1.GPIO_Label=LED_G
PC1.PinState=GPIO_PIN_SET
PC1.Signal=GPIO_Output
PC12.Mode=SD_1_bit
PC12.Signal=SDMMC1_CK
PC2_C.GPIOParameters=PinState,GPIO_Label
PC2_C.GPIO_Label=LED_B
PC2_C.PinState=GPIO_PIN_SET
PC2_C.Signal=GPIO_Output
PC6.GPIOParameters=GPIO_Speed
PC6.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PC6.Mode=Slave_8_bits_External_Synchro
PC6.Signal=DCMI_D0
PC7.GPIOParameters=GPIO_Speed
PC7.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PC7.Mode=Slave_8_bits_External_Synchro
PC7.Signal=DCMI_D1
PC8.Mode=SD_1_bit
PC8.Signal=SDMMC1_D0
PD0.GPIOParameters=GPIO_Label
PD0.GPIO_Label=SD_CD
PD0.Signal=GPIO_Input
PD12.GPIOParameters=GPIO_Label
PD12.GPIO_Label=WIFI_RESET_N
PD12.Signal=GPIO_Output
PD13.GPIOParameters=GPIO_PuPd,GPIO_Label,GPIO_ModeDefaultEXTI
PD13.GPIO_Label=WIFI_INT_N
PD13.GPIO_ModeDefaultEXTI=GPIO_MODE_IT_FALLING
PD13.GPIO_PuPd=GPIO_PULLUP
PD13.Signal=GPXTI13
PD2.Mode=SD_1_bit
PD2.Signal=SDMMC1_CMD
PD7.GPIOParameters=GPIO_Label
PD7.GPIO_Label=DCMI_PWDN
PD7.Signal=GPIO_Output
PE0.GPIOParameters=GPIO_Speed
PE0.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE0.Mode=Slave_8_bits_External_Synchro
PE0.Signal=DCMI_D2
PE1.GPIOParameters=GPIO_Speed
PE1.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE1.Mode=Slave_8_bits_External_Synchro
PE1.Signal=DCMI_D3
PE4.GPIOParameters=GPIO_Speed
PE4.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE4.Mode=Slave_8_bits_External_Synchro
PE4.Signal=DCMI_D4
PE5.GPIOParameters=GPIO_Speed
PE5.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE5.Mode=Slave_8_bits_External_Synchro
PE5.Signal=DCMI_D6
PE6.GPIOParameters=GPIO_Speed
PE6.GPIO_Speed=GPIO_SPEED_FREQ_VERY_HIGH
PE6.Mode=Slave_8_bits_External_Synchro
PE6.Signal=DCMI_D7
PH0-OSC_IN\ (PH0).Mode=HSE-External-Oscillator
PH0-OSC_IN\ (PH0).Signal=RCC_OSC_IN
PH1-OSC_OUT\ (PH1).Mode=HSE-External-Oscillator
PH1-OSC_OUT\ (PH1).Signal=RCC_OSC_OUT
RCC.HSE_VALUE=12000000
RCC.SYSCLKFreq_VALUE=480000000
RCC.SYSCLKSource=RCC_SYSCLKSOURCE_PLLCLK
board=custom

File drone-payload-fw/Core/Src/gpio.c:

/**
  ******************************************************************************
  * File Name          : gpio.c
  * Description        : This file provides code for the configuration
  *                      of all used GPIO pins.
  ******************************************************************************
  * @attention
  *
  * <h2><center>&copy; Copyright (c) 2020 STMicroelectronics.
  * All rights reserved.</center></h2>
  *
  * This software component is licensed by ST under Ultimate Liberty license
  * SLA0044, the "License"; You may not use this file except in compliance with
  * the License. You may obtain a copy of the License at:
  *                             www.st.com/SLA0044
  *
  ******************************************************************************
  */

/* Includes ------------------------------------------------------------------*/
#include "gpio.h"
/* USER CODE BEGIN 0 */

/* USER CODE END 0 */

/*----------------------------------------------------------------------------*/
/* Configure GPIO                                                             */
/*----------------------------------------------------------------------------*/
/* USER CODE BEGIN 1 */

/* USER CODE END 1 */

/** Configure pins
     PH0-OSC_IN (PH0)   ------> RCC_OSC_IN
     PH1-OSC_OUT (PH1)   ------> RCC_OSC_OUT
     PA13 (JTMS/SWDIO)   ------> DEBUG_JTMS-SWDIO
     PA14 (JTCK/SWCLK)   ------> DEBUG_JTCK-SWCLK
*/
void MX_GPIO_Init(void)
{

  GPIO_InitTypeDef GPIO_InitStruct = {0};

  /* GPIO Ports Clock Enable */
  __HAL_RCC_GPIOE_CLK_ENABLE();
  __HAL_RCC_GPIOC_CLK_ENABLE();
  __HAL_RCC_GPIOH_CLK_ENABLE();
  __HAL_RCC_GPIOA_CLK_ENABLE();
  __HAL_RCC_GPIOB_CLK_ENABLE();
  __HAL_RCC_GPIOD_CLK_ENABLE();

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOC, LED_R_Pin|LED_G_Pin|LED_B_Pin, GPIO_PIN_SET);

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOA, WIFI_CHIP_EN_Pin|DCMI_RESET_Pin, GPIO_PIN_RESET);

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(SPI2_NSS_GPIO_Port, SPI2_NSS_Pin, GPIO_PIN_RESET);

  /*Configure GPIO pin Output Level */
  HAL_GPIO_WritePin(GPIOD, WIFI_RESET_N_Pin|DCMI_PWDN_Pin, GPIO_PIN_RESET);

  /*Configure GPIO pins : PE2 PE3 PE7 PE8
                           PE9 PE10 PE11 PE12
                           PE13 PE14 PE15 */
  GPIO_InitStruct.Pin = GPIO_PIN_2|GPIO_PIN_3|GPIO_PIN_7|GPIO_PIN_8
                          |GPIO_PIN_9|GPIO_PIN_10|GPIO_PIN_11|GPIO_PIN_12
                          |GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOE, &GPIO_InitStruct);

  /*Configure GPIO pins : PC13 PC14 PC15 PC3
                           PC4 PC5 PC9 PC10
                           PC11 */
  GPIO_InitStruct.Pin = GPIO_PIN_13|GPIO_PIN_14|GPIO_PIN_15|GPIO_PIN_3
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_9|GPIO_PIN_10
                          |GPIO_PIN_11;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

  /*Configure GPIO pins : PCPin PCPin PCPin */
  GPIO_InitStruct.Pin = LED_R_Pin|LED_G_Pin|LED_B_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(GPIOC, &GPIO_InitStruct);

  /*Configure GPIO pins : PA2 PA3 PA7 PA9
                           PA11 PA12 PA15 */
  GPIO_InitStruct.Pin = GPIO_PIN_2|GPIO_PIN_3|GPIO_PIN_7|GPIO_PIN_9
                          |GPIO_PIN_11|GPIO_PIN_12|GPIO_PIN_15;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pins : PAPin PAPin */
  GPIO_InitStruct.Pin = WIFI_CHIP_EN_Pin|DCMI_RESET_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(GPIOA, &GPIO_InitStruct);

  /*Configure GPIO pins : PB0 PB1 PB2 PB3
                           PB4 PB5 */
  GPIO_InitStruct.Pin = GPIO_PIN_0|GPIO_PIN_1|GPIO_PIN_2|GPIO_PIN_3
                          |GPIO_PIN_4|GPIO_PIN_5;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOB, &GPIO_InitStruct);

  /*Configure GPIO pin : PtPin */
  GPIO_InitStruct.Pin = SPI2_NSS_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(SPI2_NSS_GPIO_Port, &GPIO_InitStruct);

  /*Configure GPIO pins : PD8 PD9 PD10 PD11
                           PD14 PD15 PD1 PD3
                           PD4 PD5 PD6 */
  GPIO_InitStruct.Pin = GPIO_PIN_8|GPIO_PIN_9|GPIO_PIN_10|GPIO_PIN_11
                          |GPIO_PIN_14|GPIO_PIN_15|GPIO_PIN_1|GPIO_PIN_3
                          |GPIO_PIN_4|GPIO_PIN_5|GPIO_PIN_6;
  GPIO_InitStruct.Mode = GPIO_MODE_ANALOG;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(GPIOD, &GPIO_InitStruct);

  /*Configure GPIO pins : PDPin PDPin */
  GPIO_InitStruct.Pin = WIFI_RESET_N_Pin|DCMI_PWDN_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_OUTPUT_PP;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  GPIO_InitStruct.Speed = GPIO_SPEED_FREQ_LOW;
  HAL_GPIO_Init(GPIOD, &GPIO_InitStruct);

  /*Configure GPIO pin : PtPin */
  GPIO_InitStruct.Pin = WIFI_INT_N_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_IT_FALLING;
  GPIO_InitStruct.Pull = GPIO_PULLUP;
  HAL_GPIO_Init(WIFI_INT_N_GPIO_Port, &GPIO_InitStruct);

  /*Configure GPIO pin : PtPin */
  GPIO_InitStruct.Pin = SD_CD_Pin;
  GPIO_InitStruct.Mode = GPIO_MODE_INPUT;
  GPIO_InitStruct.Pull = GPIO_NOPULL;
  HAL_GPIO_Init(SD_CD_GPIO_Port, &GPIO_InitStruct);

  /* EXTI interrupt init*/
  HAL_NVIC_SetPriority(EXTI15_10_IRQn, 9, 0);
  HAL_NVIC_EnableIRQ(EXTI15_10_IRQn);

}

/* USER CODE BEGIN 2 */

/* USER CODE END 2 */

/************************ (C) COPYRIGHT STMicroelectronics *****END OF FILE****/

## Commit log

2020-11-28 Set theme jekyll-theme-time-machine
2020-11-30 commit from base repos (DS_Project, DS_proj_fw)
    project contributed by
    @shenhavov
    @danblana
2020-12-05 code rearrangement
    1. code constants and util methods were moved to new code files
    2. gitignore file was updtaed
2020-12-05 Imu data is exported to csv file
2020-12-05 Fps value is added to pyplot
2020-12-08 adding curr fps display output
2020-12-26 1. changing i2c2 definitions - 100kHz 2. displaying the frames delay on pyplot
2020-12-27 1. ground_station_main.py - merging SOs ROS additions 2. fixing winc include paths - for linux compatibility 3. README.md updated
2020-12-27 updating version and README.md
2020-12-30 adding raw2plot.py
2020-12-30 adding cad dir
2021-01-01 adding documents and datasheets
2021-01-01 removing doc file
